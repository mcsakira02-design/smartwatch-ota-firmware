# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: project +hex
  AfterMake: fromelf --bin --output full.bin "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../01_APP/User_Init;../01_APP/User_Init/Platform_IO_Register;../01_APP/User_Init/User_Task_Config;../01_APP/User_Display;../01_APP/User_ExternflashManage;../01_APP/User_ExternflashManage/Platform;../01_APP/User_ExternflashManage/Platform/Externflash_port;../01_APP/User_Sensor/Platform/motion;../01_APP/User_Sensor/Platform/temp_hui_port/;../01_APP/User_Sensor/Platform/hartrate;../01_APP/User_Sensor/Platform/airpressure;..\01_APP\User_Display\Platform\Dispaly;..\01_APP\User_Display\Platform\TouchPad;../01_APP/User_Sensor/;../02_BSP_Platform/Bsp_Drivers/AirPressure/Driver/Inc;../02_BSP_Platform/Bsp_Drivers/Disp/ST7789/Driver/Inc;../02_BSP_Platform/Bsp_Drivers/Disp/ST7789/Driver/Src;../02_BSP_Platform/Bsp_Drivers/ExternStorage_Flash/config;../02_BSP_Platform/Bsp_Drivers/ExternStorage_Flash/driver/W25Q64/Src;../02_BSP_Platform/Bsp_Drivers/ExternStorage_Flash/driver/W25Q64/Inc;../02_BSP_Platform/Bsp_Drivers/ExternStorage_Flash/handler/Src;../02_BSP_Platform/Bsp_Drivers/ExternStorage_Flash/handler/Inc;../02_BSP_Platform/Bsp_Drivers/Hartrate/Driver/Inc;../02_BSP_Platform/Bsp_Drivers/Hartrate/Driver/Src;../02_BSP_Platform/Bsp_Drivers/Motion_processing_sensor/mpu6050;../02_BSP_Platform/Bsp_Drivers/Motion_processing_sensor/mpu6050/driver/Inc;../02_BSP_Platform/Bsp_Drivers/Motion_processing_sensor/mpu6050/driver/Src;../02_BSP_Platform/Bsp_Drivers/Motion_processing_sensor/mpu6050/handler/Inc;../02_BSP_Platform/Bsp_Drivers/Motion_processing_sensor/mpu6050/handler/Src;../02_BSP_Platform/Bsp_Drivers/Sensor_Temphumi/driver/Aht21/Inc;../02_BSP_Platform/Bsp_Drivers/Sensor_Temphumi/driver/Aht21/Src;../02_BSP_Platform/Bsp_Drivers/Sensor_Temphumi/handler/Inc;../02_BSP_Platform/Bsp_Drivers/Sensor_Temphumi/handler/Src;../02_BSP_Platform/Bsp_Drivers/TouchPad/CST816T/Driver/Inc;../02_BSP_Platform/Bsp_Drivers/TouchPad/CST816T/Driver/Src;../02_BSP_Platform/Platform_Interface/airpressure/bsp_adapter_port_airpressure;../02_BSP_Platform/Platform_Interface/airpressure/bsp_wrapper_airpressure;../02_BSP_Platform/Platform_Interface/display/bsp_wrapper_display;../02_BSP_Platform/Platform_Interface/display/bsp_adapter_port_display;../02_BSP_Platform/Platform_Interface/flash/bsp_wrapper_flash;../02_BSP_Platform/Platform_Interface/flash/bsp_adapter_port_flash;../02_BSP_Platform/Platform_Interface/hartrate/bsp_wrapper_hartrate;../02_BSP_Platform/Platform_Interface/hartrate/bsp_adapter_port_hartrate;../02_BSP_Platform/Platform_Interface/motion/bsp_wrapper_motion;../02_BSP_Platform/Platform_Interface/motion/bsp_adapter_port_motion;../02_BSP_Platform/Platform_Interface/temp_humi/bsp_adapter_port_temp_humi;../02_BSP_Platform/Platform_Interface/temp_humi/bsp_wrapper_temp_humi;../02_BSP_Platform/Platform_Interface/touchpad/bsp_adapter_port_touchpad;../02_BSP_Platform/Platform_Interface/touchpad/bsp_wrapper_touchpad;../02_BSP_Platform/Bsp_Integration/mpu6050_Integration;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/os_adapter/FreeRTOS/inc;../Middlewares/os_adapter/inc;../Middlewares/os_adapter/shared/inc;../Middlewares/LVGL/lvgl;../Middlewares/LVGL/lvgl/src;../Middlewares/LVGL/lvgl/examples/porting;../Middlewares/LVGL/lvgl/demos/widgets;../Middlewares/LVGL/LVGL_ui;../Middlewares/LVGL;../Middlewares/LVGL/LVGL_ui/analogclock;../02_MCU_Platform/MCU_Startup;../02_MCU_Platform/MCU_ExceptionalHandler;../02_MCU_Platform/MCU_Core_SPI/spi_port;../02_MCU_Platform/MCU_Core_IIC/i2c_port;../02_MCU_Platform/MCU_Core_GPIO/gpio_port;../03_Config/Smart_WatchVersion;../DebugComponent/RTT;../DebugComponent/easylogger/inc;../Drivers/CMSIS/Include;../DebugComponent;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Platform;../User_Task/User_ExternflashManage;../User_Task/User_ExternflashManage/Platform/Externflash_port;../User_Task/User_Sensor/Platform/motion;../Core/Core_Platform;../Core/Core_Platform/i2c_port;../Core/Core_Platform/spi_port;../Core/Inc;..\02_MCU_Platform\MCU_Core_ADC\adc_port;..\02_MCU_Platform\MCU_Core_GPIO\gpio_port
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: project\project.sct
  group 01_APP/User_App
    ../01_APP/User_Init/: user_init.c
    ../01_APP/User_Display/: user_display.c lvgl_sensor_interface.c lvgl_usage_example.c
    ../01_APP/User_ExternflashManage/: user_externflashManage.c
    ../01_APP/User_Sensor/: user_sensor.c
    ../01_APP/User_Isr_handlers/: user_isr_handlers.c
    ../01_APP/User_Init/User_Task_Config/: user_task_reso_config.c
    ../01_APP/User_Init/Platform_IO_Register/: user_periph_setup.c
  group 01_APP/User_Platform
    ../01_APP/User_ExternflashManage/Platform/Externflash_port/: externflash_manage_port.c
    ../01_APP/User_Sensor/Platform/temp_hui_port/: temp_hui_port.c
    ../01_APP/User_Sensor/Platform/motion/: motion_port.c
    ../01_APP/User_Sensor/Platform/hartrate/: hartrate_port.c
    ../01_APP/User_Sensor/Platform/airpressure/: airpressure_port.c
    ../01_APP/User_Display/Platform/TouchPad/: touchpad_port.c
    ../01_APP/User_Display/Platform/Dispaly/: display_port.c
  group 02_BSP_Platform/BSP_Drivers
    ../02_BSP_Platform/Bsp_Drivers/Disp/ST7789/Driver/Src/: bsp_st7789_driver.c fonts.c
    ../02_BSP_Platform/Bsp_Drivers/ExternStorage_Flash/handler/Src/: bsp_flash_handler.c
    ../02_BSP_Platform/Bsp_Drivers/ExternStorage_Flash/driver/W25Q64/Src/: bsp_w25q64_driver.c
    ../02_BSP_Platform/Bsp_Drivers/Hartrate/Driver/Src/: bsp_em7028_driver.c
    ../02_BSP_Platform/Bsp_Drivers/Motion_processing_sensor/mpu6050/driver/Src/: bsp_mpuxxx_driver.c circular_buffer.c
    ../02_BSP_Platform/Bsp_Drivers/Motion_processing_sensor/mpu6050/handler/Src/: bsp_mpuxxx_handler.c
    ../02_BSP_Platform/Bsp_Drivers/Sensor_Temphumi/handler/Src/: bsp_temp_humi_xxx_handler.c
    ../02_BSP_Platform/Bsp_Drivers/TouchPad/CST816T/Driver/Src/: bsp_cst816t_driver.c bsp_cst816t_calibration.c touch_calibration_example.c touch_calibration_ui.c
    ../02_BSP_Platform/Bsp_Drivers/Sensor_Temphumi/driver/Aht21/Src/: bsp_aht21_driver.c
    ../02_BSP_Platform/Bsp_Drivers/AirPressure/Driver/Src/: bsp_spl06_driver.c
  group 02_BSP_Platform/Platform_Interface
    ../02_BSP_Platform/Platform_Interface/motion/bsp_wrapper_motion/: bsp_wrapper_motion.c
    ../02_BSP_Platform/Platform_Interface/temp_humi/bsp_wrapper_temp_humi/: bsp_wrapper_temp_humi.c
    ../02_BSP_Platform/Platform_Interface/touchpad/bsp_wrapper_touchpad/: bsp_wrapper_touchpad.c
    ../02_BSP_Platform/Platform_Interface/display/bsp_wrapper_display/: bsp_wrapper_display.c
    ../02_BSP_Platform/Platform_Interface/flash/bsp_wrapper_flash/: bsp_wrapper_flash.c
    ../02_BSP_Platform/Platform_Interface/hartrate/bsp_wrapper_hartrate/: bsp_wrapper_hartrate.c
    ../02_BSP_Platform/Platform_Interface/motion/bsp_adapter_port_motion/: bsp_adapter_port_motion.c
    ../02_BSP_Platform/Platform_Interface/display/bsp_adapter_port_display/: bsp_adapter_port_display.c
    ../02_BSP_Platform/Platform_Interface/hartrate/bsp_adapter_port_hartrate/: bsp_adapter_port_hartrate.c
    ../02_BSP_Platform/Platform_Interface/touchpad/bsp_adapter_port_touchpad/: bsp_adapter_port_touchpad.c
    ../02_BSP_Platform/Platform_Interface/flash/bsp_adapter_port_flash/: bsp_adapter_port_flash.c
    ../02_BSP_Platform/Platform_Interface/temp_humi/bsp_adapter_port_temp_humi/: bsp_adapter_port_temp_humi.c
    ../02_BSP_Platform/Platform_Interface/airpressure/bsp_adapter_port_airpressure/: bsp_adapter_port_airpressure.c
    ../02_BSP_Platform/Platform_Interface/airpressure/bsp_wrapper_airpressure/: bsp_wrapper_airpressure.c
  group 02_BSP_Platform/Bsp_Integration
    ../02_BSP_Platform/Bsp_Integration/mpu6050_Integration/: mpu6050_integration.c
  group 02_OS_Platform/OS_Wrapper
    ../02_OS_Platform/OS_Wrapper/src/: osal_heap.c osal_mutex.c osal_queue.c osal_sema.c osal_task.c osal_timer.c
  group 02_OS_Platform/OS_Implementation
    ../02_OS_Platform/OS_Implementation/FreeRTOS/src/: os_impl_heap.c os_impl_mutex.c os_impl_queue.c os_impl_sema.c os_impl_task.c os_impl_timer.c
  group 02_Middlewares_Platform/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group 02_Middlewares_Platform/LVGL/lvgl
    ../Middlewares/LVGL/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
    ../Middlewares/LVGL/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    ../Middlewares/LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../Middlewares/LVGL/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middlewares/LVGL/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../Middlewares/LVGL/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../Middlewares/LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Middlewares/LVGL/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../Middlewares/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/LVGL/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/LVGL/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/lvgl/src/extra/others/msg/: lv_msg.c
    ../Middlewares/LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/LVGL/lvgl/src/extra/: lv_extra.c
    ../Middlewares/LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group 02_Middlewares_Platform/LVGL/ui
    ../Middlewares/LVGL/LVGL_ui/: events_init.c gui_guider.c setup_scr_Electronicfence.c setup_scr_error.c setup_scr_Heart.c setup_scr_menu_1.c setup_scr_menu_2.c setup_scr_menu_3.c setup_scr_Message.c setup_scr_NFCCard.c setup_scr_QrCode.c setup_scr_Set.c setup_scr_Systeamupdate.c setup_scr_Systeamupdate_cheak.c setup_scr_top_lap.c setup_scr_WatchGiral_1.c setup_scr_WatchGiral_2.c setup_scr_WatchGiral_3.c widgets_init.c
    ../Middlewares/LVGL/LVGL_ui/analogclock/: lv_analogclock.c
    ../Middlewares/LVGL/LVGL_ui/guider_customer_fonts/: lv_customer_font_alimama_12.c lv_customer_font_alimama_16.c lv_customer_font_alimama_36.c lv_customer_font_digitaldreamfatnarrow_36.c lv_customer_font_interttf_10.c lv_customer_font_interttf_16.c lv_customer_font_interttf_24.c lv_customer_font_interttf_82.c
    ../Middlewares/LVGL/LVGL_ui/images/: _biaopan1_100x100.c _BIGHeart_alpha_46x43.c _BT32_alpha_32x32.c _Ellipse_40x40.c _error_alpha_48x48.c _fen_alpha_70x5.c _foot16x16_alpha_16x16.c _Frame_50x50.c _heart16x16_alpha_16x16.c _KLL16x16_alpha_16x16.c _liangdu_40x40.c _location_alpha_32x32.c _location20x20_alpha_20x20.c _location32x32_alpha_16x16.c _logo_100x100.c _M_50x50.c _nfc_alpha_32x32.c _NFC32x32_alpha_32x32.c _pa_alpha_16x16.c _power_hight_alpha_32x32.c _qrcode32x32_alpha_32x32.c _set32x32_alpha_32x32.c _Sfen_alpha_21x6.c _sheshidu_alpha_10x10.c _Stime_alpha_16x8.c _syteam32x32_alpha_32x32.c _taiwan_alpha_32x32.c _time_alpha_40x5.c _tiwen_alpha_16x16.c _wather16x16_alpha_16x16.c _wtime_30x50.c
  group 02_MCU_Platform/Core_Platform/Cluster
    ../02_MCU_Platform/MCU_Core_IIC/i2c_port/: i2c_port.c
    ../02_MCU_Platform/MCU_Core_SPI/spi_port/: spi_port.c
    ../02_MCU_Platform/MCU_Core_ADC/adc_port/: adc_port.c
    ../02_MCU_Platform/MCU_Core_GPIO/gpio_port/: gpio_port.c
  group 03_Config/Smart_watch_version
    ../03_Config/Smart_WatchVersion/: smart_watchversion.c
  group Debug/Port
    ../DebugComponent/: Debug.c
  group Debug/RTT
    ../DebugComponent/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../DebugComponent/easylogger/port/: elog_port.c
    ../DebugComponent/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: delay.c iic_hal.c main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
